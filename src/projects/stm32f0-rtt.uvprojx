# Keil uVision project stm32f0-rtt.uvprojx, settings and files
target stm32f030-rtt (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32f0-rtt
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F030X8, RT_USING_ARM_LIBC
  c include: ..\cpu;..\cpu\inc;..\cpu\cmsis_inc;..\rtt\include;..\rtt\portable;..\mshell;..\drivers;..\lib;..\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group app
    ../app/: main.c
  group system
    ../system/: system.c config.h 25-50-NAS-V6.h 25-50-NAS-V5.h 8-16-NAS-V21.0.h
  group rtt/src
    ../rtt/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group rtt/portable
    ../rtt/portable/: board.c rtconfig.h context_rvds.S cpuport.c
  group drivers
    ../drivers/: driver_config.c dev.c uart.c gpio.c exti.c flash.c iic.c ir.c timer.c 74hc595.c
  group mshell
    ../mshell/: mshell.c mshell_dir.c mshell_parse.c mshell_permission.c mshell_cmd.c mshell_portable.c test_cmd.c
  group cpu
    ../cpu/: stm32f0xx_it.c cpu.c startup_stm32f030x8.s system_stm32f0xx.c
    ../cpu/src/: stm32f0xx_adc.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group lib
    ../lib/: cbuffer.c lib.c
  group 说明
    ../说明/: 说明.txt
